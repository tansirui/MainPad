# Keil uVision project uCOS-II.uvprojx, settings and files
target uCOS-II (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uCOS-II
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\APP;..\BSP;..\CMSIS;..\FWLIB\inc;..\FWLIB\src;..\BSP\Matrix_key;..\BSP\OLED;..\BSP\TIM;..\BSP\USART;..\BSP\ADC;..\BSP\Peripherals;..\BSP\Systems;..\BSP\USART;..\APP\gps;..\Virtual Com\STM32_USB-FS-Device_Driver\inc;..\Virtual Com\STM32_USB-FS-Device_Driver\src;..\Virtual Com\USB_Lib;..\BSP\SDIO;..\BSP\OV7670;..\BSP\SPI;..\BSP\NRF24L01
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../CMSIS/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group APP
    ../APP/: main.c stm32f10x_it.c stm32f10x_conf.h
  group BSP
    ../BSP/Peripherals/: led.c key.c
    ../BSP/USART/: usart1.c usart2.c
    ../BSP/TIM/: tim5.c motor.c capture.c
    ../BSP/ADC/: adc_dma.c
    ../BSP/OLED/: oled.c
    ../BSP/Systems/: delay.c
    ../BSP/SDIO/: sdio_sdcard.c
    ../BSP/OV7670/: ov7670.c sccb.c
    ../BSP/SPI/: spi_flash.c spi2.c
    ../BSP/NRF24L01/: nRF24L01.c
    ../BSP/: Ultrasonic.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c stm32f10x_tim.c stm32f10x_exti.c stm32f10x_dma.c stm32f10x_adc.c stm32f10x_sdio.c stm32f10x_spi.c
  group Doc
    ../Doc/: 说明.txt
  group USB-FS-Device_Driver
    ../Virtual Com/STM32_USB-FS-Device_Driver/src/: usb_core.c usb_init.c usb_int.c usb_mem.c usb_regs.c usb_sil.c
  group Virtual_com
    ../Virtual Com/USB_Lib/: hw_config.c usb_endp.c usb_pwr.c usb_desc.c usb_istr.c usb_prop.c
