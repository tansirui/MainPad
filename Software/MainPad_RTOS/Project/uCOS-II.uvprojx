# Keil uVision project uCOS-II.uvprojx, settings and files
target uCOS-II (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: STM32F103VE STMicroelectronics
  pack: Keil.STM32F1xx_DFP.2.1.0
  cpu: IROM(0x08000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M3") CLOCK(12000000) ELITTLE
  output: uCOS-II
  c flags: Optim=1 OneElfS=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: STM32F10X_HD, USE_STDPERIPH_DRIVER
  c include: ..\uCOS-II\Source;..\uCOS-II\Ports\RealView;..\uCOS-II\Config;..\FWLIB\inc;..\FWLIB\src;..\CMSIS;..\APP;..\BSP\Peripherals;..\BSP\USART;..\BSP\Systems;..\BSP\OLED
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x80000
  memory RVCT9: RAM 0x20000000 size 0x10000
  group STARTUP
    ../CMSIS/: startup_stm32f10x_hd.s
  group CMSIS
    ../CMSIS/: core_cm3.c system_stm32f10x.c
  group APP
    ../APP/: main.c stm32f10x_it.c stm32f10x_conf.h app_task.c bsp.c
    ../uCOS-II/Config/: app_cfg.c
  group BSP
    ../BSP/Peripherals/: led.c key.c
    ../BSP/USART/: usart1.c
    ../BSP/Systems/: delay.c
    ../BSP/OLED/: oled.c
  group FWLIB
    ../FWLIB/src/: misc.c stm32f10x_rcc.c stm32f10x_gpio.c stm32f10x_usart.c
  group Doc
    ../Doc/: 说明.txt
  group UCOSII\Config
    ../uCOS-II/Config/: app_cfg.h os_cfg.h
  group UCOSII\Source
    ../uCOS-II/Source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c
  group UCOSII\Ports
    ../uCOS-II/Ports/RealView/: os_cpu_a.asm os_cpu_c.c os_cpu.h
